DESCRIPTION = "Image to load over sdp"
LICENSE = "MIT"

inherit fit-package

INITRAMFS_IMAGE = "sdb8000-initramfs"
