FILESEXTRAPATHS:prepend := "${THISDIR}/psplash:"
