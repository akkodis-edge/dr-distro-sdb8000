FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-sdb8000-support-legacy-rtc-format-on-older-firmware.patch"
