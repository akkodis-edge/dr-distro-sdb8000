COMPATIBLE_MACHINE = "sdb8000"
OPTEEMACHINE = "imx"
