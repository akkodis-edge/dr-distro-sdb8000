COMPATIBLE_MACHINE = "sdb8000"
OPTEEMACHINE = "imx"
EXTRA_OEMAKE:append:sdb8000 = " PLATFORM_FLAVOR=mx8mmevk"
