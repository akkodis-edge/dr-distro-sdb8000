# Build qt6 with sqlite3 support for maliit-keyboard
PACKAGECONFIG:append = " sql-sqlite"
