# DISTRO_FEATURES_FILTER_NATIVE are not considered in features_check.bbclass
# Append mandatory wayland here.
DISTRO_FEATURES_NATIVE:append = " wayland"
