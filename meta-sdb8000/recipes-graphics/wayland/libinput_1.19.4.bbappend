# Fix missing dependency
DEPENDS:append = " wayland-native"
