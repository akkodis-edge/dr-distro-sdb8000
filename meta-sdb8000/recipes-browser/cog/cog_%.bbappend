FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-popup-menu-not-appearing-when-using-touchscreen.patch"
