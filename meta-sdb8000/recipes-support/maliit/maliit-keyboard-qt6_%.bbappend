# Pull in qt5compat libraries
RDEPENDS:${PN}:append = " qt5compat"
