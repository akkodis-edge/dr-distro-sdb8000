DESCRIPTION = "Image to load over sdp"
LICENSE = "MIT"

inherit fit-package

INITRAMFS_IMAGE = "imx8mm-evk-initramfs"
